# Keil uVision project blink_lpc.uvproj, settings and files
target LPC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: blink_lpc
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LPC2105_simulador
  c include: ../../src;../src_lpc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Comun
    ../../src/: main.c drv_leds.c drv_leds.h drv_tiempo.c drv_tiempo.h hal_gpio.h hal_tiempo.h board.h rt_evento_t.h rt_fifo.h rt_fifo.c drv_consumo.c drv_consumo.h drv_monitor.h drv_monitor.c hal_ext_int.h rt_GE.c rt_GE.h srv_alarm.c srv_alarm.h drv_botones.c drv_botones.h hal_WDT.h drv_SC.c drv_SC.h hal_random.h simon.c simon.h Counter_strike.c Counter_strike.h test.c test.h
  group Dependientes
    ../src_lpc/: board_lpc.h hal_gpio_lpc.c reserva_gpio_lpc2105.h hal_tiempo_lpc.c hal_consumo_lpc.c hal_ext_int_lpc.c hal_WDT_lpc.c hal_random_lpc.c
  group Inicio
    ../src_lpc/: Startup.s
target LPC_release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: as above
  output: blink_lpc
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LPC2105_simulador
  c include: ../../src;../src_lpc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
